# Keil uVision project ossw-bootloader-s120.uvprojx, settings and files
target nrf51822_xxaa (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ossw-bootloader-s120 +hex
  c flags: Optim=4
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S110 BOARD_CUSTOM BSP_DEFINES_ONLY NRF51 BSP_SIMPLE SOFTDEVICE_PRESENT
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002800 size 0x1780
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../: dfu_ble_svc.c main.c
  group Documentation
    ../: Abstract.txt license.txt
  group SDK modifications
    ../bsp/: bsp.c bsp.h custom_board.h boards.h
    ../: dfu_transport_ble.c bootloader.c bootloader.h dfu_init.h dfu_init_template.c dfu_single_bank.c
  group Libraries
    ../: mlcd.c mlcd.h spi.h spi.c
software components: CMSIS:CORE 3.40.0, Device:Startup 7.1.0, nRF_BLE:BLE_Modules:ble_advdata 2.0.0, nRF_BLE:BLE_Modules:ble_common 2.0.0, nRF_BLE:BLE_Modules:ble_conn_params 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_BLE:BLE_Services:ble_dfu 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Libraries:DFU:dfu_bootloader_settings 2.0.0, nRF_Libraries:DFU:dfu_bootloader_util 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_scheduler 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_timer_with_app_scheduler 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:crc16 2.0.0, nRF_Libraries:hci_mem_pool 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:sd_handler_with_app_scheduler 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s120 2.0.0
