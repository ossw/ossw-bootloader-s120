# Keil uVision project ossw-bootloader-smaq-nrf51.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ossw-bootloader-smaq-nrf51 +hex
  c flags: Optim=4
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S130 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../: bootloader.c dfu_init_template.c dfu_single_bank.c dfu_transport_ble.c bootloader.h dfu_init.h dfu_ble_svc.c main.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3, nRF_BLE:BLE_Modules:ble_advdata 3.0.1, nRF_BLE:BLE_Modules:ble_common 3.0.1, nRF_BLE:BLE_Modules:ble_conn_params 3.0.1, nRF_BLE:BLE_Modules:ble_service_common 3.0.1, nRF_BLE:BLE_Services:ble_dfu 3.0.1, nRF_BLE:BLE_Services:ble_nus 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:pstorage 3.0.1, nRF_Drivers:spi_slave 3.0.1, nRF_Libraries:DFU:dfu_bootloader_settings 3.0.1, nRF_Libraries:DFU:dfu_bootloader_util 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_scheduler 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_timer_with_app_scheduler 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:crc16 3.0.1, nRF_Libraries:hci_mem_pool 3.0.1, nRF_Libraries:nrf_assert 3.0.1, nRF_SoftDevice:Internal:sd_common 1.1.4, nRF_SoftDevice:Internal:sd_handler_with_app_scheduler 1.1.4, nRF_SoftDevice:Internal:softdevice_present 1.1.4, nRF_SoftDevice:s130 1.0.1
